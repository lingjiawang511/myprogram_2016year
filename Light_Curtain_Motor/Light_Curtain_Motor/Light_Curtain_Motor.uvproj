# Keil uVision project Light_Curtain_Motor.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F410 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(50000000)
  output: Light_Curtain_Motor +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group Source Group 1
    ./: main.c Motor_Control.c Timer.c
    ../: 调试要求.txt
