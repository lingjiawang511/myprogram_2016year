# Keil uVision project belt_control_app.uvprojx, settings and files
target belt_control_app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: belt_control_app +hex
  AfterMake: fromelf.exe ".\OBJ\belt_control_app.axf" --bin --output "..\belt_control_app.bin"
  AfterMake: ..\binHEBING\post.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,APP_USE_IAP
  c misc: --C99
  c include: ..\BSP\EXTI;..\include;..\Libraries\CORE;..\Libraries\FWLIB\inc;..\USER;..\USER\delay;..\USER\led
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x7c000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c TIM.C key.c belt.c stm32f4xx_it.c usart.c flash_if.c
    ../USER/led/: led.c
    ../USER/delay/: delay.c
  group LIBRARIES
    ../Libraries/FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c
  group CMSIS
    ../USER/: system_stm32f4xx.c
  group STARTUP
    ../Libraries/CORE/: startup_stm32f40_41xxx.s
software components: CMSIS:CORE 5.1.2
