# Keil uVision project SHT20_control.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SHT20_control +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\BSP\EXTI;..\include;..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\USER;..\USER\delay;..\USER\led;..\USER\IIC;..\BSP\IIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c crc16.c key.c stm32f10x_it.c TIM.C usart.c communication.c LCD_ZK.c 24cxx.c SHT2X.c
    ../USER/delay/: delay.c
    ../USER/led/: led.c
  group LIBRARIES
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group remark
    ../: 调试备注.txt
